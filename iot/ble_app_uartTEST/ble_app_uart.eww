<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040e\s112\iar\ble_app_uart_pca10040e_s112.ewp</path>
  </project>  <batchBuild/>
</workspace>